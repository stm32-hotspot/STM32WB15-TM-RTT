# IAR project WB15_TM_RTT.ewp, settings and files
configuration WB15_TM_RTT (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB15CC ST STM32WB15CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB15xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Utilities/lpm/tiny_lpm; ../Middlewares/ST/STM32_WPAN; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../Middlewares/ST/STM32_WPAN/utilities; ../Middlewares/ST/STM32_WPAN/ble/core; ../Middlewares/ST/STM32_WPAN/ble/core/auto; ../Middlewares/ST/STM32_WPAN/ble/core/template; ../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/lhci; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Utilities/sequencer; ../Middlewares/ST/STM32_WPAN/ble; ../Drivers/CMSIS/Include; ../Core/Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WB15_TM_RTT.hex
  ILINK.IlinkOutputFile: WB15_TM_RTT.out
  ILINK.IlinkIcfFile: stm32wb15xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c standby.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/RTT
    ../Core/Src/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: tm.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_hsem.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/lhci/: lhci.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
